/**
  * @file       button_device.c
  * @author     ����
  * @version    V1.0.1
  * @date       20251218
  * @brief      独立按键驱动，基于 STM32 HAL 库
  *
  * <h2><center>&copy;此文件版权归【����】所有.</center></h2>
  */

#include "button_device.h"
#include "string.h"

/// @brief      按键设备实例数组
///
/// @note
static stButtonDeviceParamTdf s_astButtonDevice[BUTTON_DEV_NUM];

/// @brief      静态参数拷贝
///
/// @param      pstInit     : 初始化参数
/// @param      emDevNum    : 设备号
///
/// @note
static void s_vButtonStaticParamCopy(stButtonStaticParamTdf *pstInit, emButtonDevNumTdf emDevNum)
{
    memcpy(&s_astButtonDevice[emDevNum].stStaticParam, pstInit, sizeof(stButtonStaticParamTdf)/sizeof(uint8_t));
}

/// @brief      读取按键原始电平
///
/// @param      emDevNum    : 设备号
///
/// @retval     原始电平状态（0/1）
///
/// @note
static uint8_t s_ucReadButtonRawLevel(emButtonDevNumTdf emDevNum)
{
    return (uint8_t)HAL_GPIO_ReadPin(s_astButtonDevice[emDevNum].stStaticParam.pstGpioBase, 
                                     s_astButtonDevice[emDevNum].stStaticParam.usGpioPin);
}

/// @brief      刷新按键状态（含消抖处理）
///
/// @param      emDevNum    : 设备号
///
/// @note       需周期性调用（建议周期10ms），真值表如下：
///             --------------------------------------------------------------------------------
///             |   原始电平   |   有效电平   |   原始状态   |   消抖后状态   |   事件         |
///             --------------------------------------------------------------------------------
///             |   Low(0)     |   Low(0)     |   Pressed    |   Pressed      |   Press        |
///             |   High(1)    |   High(1)    |   Pressed    |   Pressed      |   Press        |
///             |   High(1)    |   Low(0)     |   Released   |   Released     |   Release      |
///             |   Low(0)     |   High(1)    |   Released   |   Released     |   Release      |
///             --------------------------------------------------------------------------------
void vButtonRefreshStatus(emButtonDevNumTdf emDevNum)
{
    uint8_t                     ucRawLevel;
    emButtonStatusTdf           emRawStatus;
    stButtonRunningParamTdf     *pstRunParam    = &s_astButtonDevice[emDevNum].stRunningParam;
    stButtonStaticParamTdf      *pstStaticParam = &s_astButtonDevice[emDevNum].stStaticParam;

    // 1. 读取原始电平并转换为原始状态
    ucRawLevel  = s_ucReadButtonRawLevel(emDevNum);
    emRawStatus = (ucRawLevel == pstStaticParam->emActiveLevel) ? 
                  emButtonStatus_Pressed : emButtonStatus_Released;

    // 2. 消抖处理
    if (emRawStatus != pstRunParam->emCurrentStatus)
    {
        pstRunParam->usDebounceCounter++;
        if (pstRunParam->usDebounceCounter >= pstStaticParam->usDebounceCount)
        {
            // 消抖完成，更新状态
            pstRunParam->emLastStatus       = pstRunParam->emCurrentStatus;
            pstRunParam->emCurrentStatus    = emRawStatus;
            pstRunParam->usDebounceCounter  = 0;
        }
    }
    else
    {
        pstRunParam->usDebounceCounter      = 0;
    }

    // 3. 事件判断
    pstRunParam->emCurrentEvent = emButtonEvent_None;
    if (pstRunParam->emCurrentStatus != pstRunParam->emLastStatus)
    {
        pstRunParam->emCurrentEvent = (pstRunParam->emCurrentStatus == emButtonStatus_Pressed) ? 
                                      emButtonEvent_Press : emButtonEvent_Release;
    }
}

/// @brief      设置按键当前状态（强制更新）
///
/// @param      emStatus    : 要设置的状态
/// @param      emDevNum    : 设备号
///
/// @note
void vButtonSetCurrentStatus(emButtonStatusTdf emStatus, emButtonDevNumTdf emDevNum)
{
    s_astButtonDevice[emDevNum].stRunningParam.emLastStatus        = s_astButtonDevice[emDevNum].stRunningParam.emCurrentStatus;
    s_astButtonDevice[emDevNum].stRunningParam.emCurrentStatus     = emStatus;
    s_astButtonDevice[emDevNum].stRunningParam.usDebounceCounter   = 0;
}

/// @brief      获取按键当前状态
///
/// @param      emDevNum    : 设备号
///
/// @retval     当前状态，详见 emButtonStatusTdf 定义
///
/// @note
emButtonStatusTdf emButtonGetStatus(emButtonDevNumTdf emDevNum)
{
    return s_astButtonDevice[emDevNum].stRunningParam.emCurrentStatus;
}

/// @brief      获取按键当前事件
///
/// @param      emDevNum    : 设备号
///
/// @retval     当前事件，详见 emButtonEventTdf 定义
///
/// @note       事件为一次性触发，读取后需手动清除
emButtonEventTdf emButtonGetEvent(emButtonDevNumTdf emDevNum)
{
    emButtonEventTdf emEvent;
    
    vButtonRefreshStatus(emDevNum);
    emEvent = s_astButtonDevice[emDevNum].stRunningParam.emCurrentEvent;
    s_astButtonDevice[emDevNum].stRunningParam.emCurrentEvent = emButtonEvent_None;
    
    return emEvent;
}

/// @brief      获取多个按键当前事件
///
/// @param      emStartDevNum   : 起始设备号
/// @param      ucNum           : 连续设备数量
///
/// @retval     按键状态，最低位对应起始设备号状态，1 为被按下，0 为未被按下
///
/// @note       事件为一次性触发，读取后需手动清除
uint32_t ulButtonGetEvents(emButtonDevNumTdf emStartDevNum, uint8_t ucNum)
{
    uint16_t i;
    uint32_t ulReturnValue  = 0;
    uint32_t ulMask         = 0x00000001;
    
    if(ucNum > BUTTON_ONCE_GET_EVENT_NUM_MAX)
    {
        ucNum = BUTTON_ONCE_GET_EVENT_NUM_MAX;
    }
    
    for(i = emStartDevNum; i < emStartDevNum + ucNum; i++)
    {
        ulReturnValue <<= 1;
        if(emButtonGetEvent((emButtonDevNumTdf)i) == emButtonEvent_Press)
        {
            ulReturnValue |= ulMask;
        }
    }
    
    return ulReturnValue;
}

/// @brief      按键设备初始化
///
/// @param      pstInit     : 初始化结构体实例指针
/// @param      emDevNum    : 设备号
///
/// @retval     调用是否成功，详见 emButtonFuncErrorCodeTdf 定义
///
/// @note
emButtonFuncErrorCodeTdf emButtonDeviceInit(stButtonStaticParamTdf *pstInit, emButtonDevNumTdf emDevNum)
{
    if ((pstInit == NULL) || (emDevNum >= (emButtonDevNumTdf)BUTTON_DEV_NUM))
    {
        return emButtonFuncErrorCode_InvalidParam;
    }

    // 1. 拷贝静态参数
    s_vButtonStaticParamCopy(pstInit, emDevNum);

    // 2. 初始化动态参数
    s_astButtonDevice[emDevNum].stRunningParam.emCurrentStatus     = emButtonStatus_Released;
    s_astButtonDevice[emDevNum].stRunningParam.emLastStatus        = emButtonStatus_Released;
    s_astButtonDevice[emDevNum].stRunningParam.emCurrentEvent      = emButtonEvent_None;
    s_astButtonDevice[emDevNum].stRunningParam.usDebounceCounter   = 0;

    // 3. 返回错误码
    return emButtonFuncErrorCode_None;
}
