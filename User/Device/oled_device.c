/**
  * @file       oled_device.c
  * @author     ����
  * @version    V1.0.1
  * @date       20251130
  * @brief      OLED 驱动，基于 STM32 HAL 库
  *
  * <h2><center>&copy;此文件版权归【����】所有.</center></h2>
  */ 

#include "oled_device.h"
#include "string.h"


/// @brief      设备参数实例定义
///
/// @note
static stOledDeviceParamTdf s_astOledDeviceParam[OLED_DEVICE_NUM];


/// @brief      获取运行参数首地址
///
/// @param      emDevNum    ：设备号
///
/// @note       注意，获取的指针是只读的
const stOledRunningParamTdf *c_pstOledGetRunningParam(emOledDevNumTdf emDevNum)
{
    return &s_astOledDeviceParam[emDevNum].stRunningParam;
}

/// @brief      静态参数初始化
///
/// @param      pstStaticParam    ：输入硬件参数指针
///             emDevNum        ：设备号
///
/// @note
static void s_vOledStaticParamInit(stOledStaticParamTdf *pstStaticParam, emOledDevNumTdf emDevNum)
{
    memcpy(&s_astOledDeviceParam[emDevNum], pstStaticParam, sizeof(stOledStaticParamTdf) / sizeof(uint8_t));
}

/// @brief      IIC 起始
///
/// @param      emDevNum        ：设备号
///
/// @note
static void s_vOledIicStart(emOledDevNumTdf emDevNum)
{
    OLED_SDA_SET(emDevNum);
    OLED_SCL_SET(emDevNum);
    OLED_SDA_RESET(emDevNum);
    OLED_SCL_RESET(emDevNum);
}

/// @brief      IIC 停止
///
/// @param      emDevNum        ：设备号
///
/// @note
static void s_vOledIicStop(emOledDevNumTdf emDevNum)
{
    OLED_SCL_SET(emDevNum);
    OLED_SDA_RESET(emDevNum);
    OLED_SDA_SET(emDevNum);
}

/// @brief      IIC 等待应答
///
/// @param      emDevNum        ：设备号
///
/// @note
static void s_vOledIicWaitAck(emOledDevNumTdf emDevNum)
{
    OLED_SCL_SET(emDevNum);
    OLED_SCL_RESET(emDevNum);
}

/// @brief      IIC 发送一个字节
///
/// @param      emDevNum        ：设备号
///
/// @note
static void s_vOledIicSendByte(uint8_t ucData, emOledDevNumTdf emDevNum)
{
    uint8_t i;
    
    for(i = 0; i < 8; i++)
    {
        OLED_SCL_RESET(emDevNum);
        if((ucData & 0x80) != 0)
        {
            OLED_SDA_SET(emDevNum);
        }
        else
        {
            OLED_SDA_RESET(emDevNum);
        }
        OLED_SCL_SET(emDevNum);
        OLED_SCL_RESET(emDevNum);
        ucData <<= 1;
    }
}

/// @brief      向 OLED 写一个字节数据
///
/// @param      ucData      ：要写入的数据
///             emDevNum    ：设备号
///
/// @note
static void s_vOledWriteOneByteData(uint8_t ucData, emOledDevNumTdf emDevNum)
{
    s_vOledIicStart(emDevNum);
    s_vOledIicSendByte(0x78, emDevNum);
    s_vOledIicWaitAck(emDevNum);
    s_vOledIicSendByte(0x40, emDevNum);
    s_vOledIicWaitAck(emDevNum);
    s_vOledIicSendByte(ucData, emDevNum);
    s_vOledIicWaitAck(emDevNum);
    s_vOledIicStop(emDevNum);
}

/// @brief      向 OLED 写一个字节命令
///
/// @param      ucCmd       ：要写入的命令
///             emDevNum    ：设备号
///
/// @note
static void s_vOledWriteOneByteCmd(uint8_t ucCmd, emOledDevNumTdf emDevNum)
{
    s_vOledIicStart(emDevNum);
    s_vOledIicSendByte(0x78, emDevNum);
    s_vOledIicWaitAck(emDevNum);
    s_vOledIicSendByte(0x00, emDevNum);
    s_vOledIicWaitAck(emDevNum);
    s_vOledIicSendByte(ucCmd, emDevNum);
    s_vOledIicWaitAck(emDevNum);
    s_vOledIicStop(emDevNum);
}

/// @brief      开启显示
///
/// @param      emDevNum        ：设备号
///
/// @note
void vOledDisplayOn(emOledDevNumTdf emDevNum)
{
    s_vOledWriteOneByteCmd(0x8D, emDevNum);         // 电荷泵使能
    s_vOledWriteOneByteCmd(0x14, emDevNum);         // 开启电荷泵
    s_vOledWriteOneByteCmd(0xAF, emDevNum);         // 点亮屏幕
}

/// @brief      关闭显示
///
/// @param      emDevNum        ：设备号
///
/// @note
void vOledDisplayOff(emOledDevNumTdf emDevNum)
{
    s_vOledWriteOneByteCmd(0x8D, emDevNum);         // 电荷泵使能
    s_vOledWriteOneByteCmd(0x10, emDevNum);         // 关闭电荷泵
    s_vOledWriteOneByteCmd(0xAF, emDevNum);         // 熄灭屏幕
}

/// @brief      更新显存显示
///
/// @param      emDevNum        ：设备号
///
/// @note
void vOledRefreshFromBuffer(const uint8_t *c_pucBuffer, emOledDevNumTdf emDevNum)
{
    uint8_t i, j;
    
    for(i = 0; i < OLED_FRAME_HEIGHT; i++)
    {
        s_vOledWriteOneByteCmd(0xB0 + i, emDevNum);         // 设置行起始地址
        s_vOledWriteOneByteCmd(0x00, emDevNum);             // 设置低列起始地址
        s_vOledWriteOneByteCmd(0x10, emDevNum);             // 设置高列起始地址
        
        for(j = 0; j < OLED_FRAME_WIDTH; j++)
        {
            s_vOledWriteOneByteData(c_pucBuffer[j * OLED_FRAME_HEIGHT + i], emDevNum);
        }
    }
}

/// @brief      OLED 命令初始化
///
/// @param      emDevNum    ：设备号
///
/// @note
void vOledCmdInit(emOledDevNumTdf emDevNum)
{
	s_vOledWriteOneByteCmd(0xAE, emDevNum);//--turn off oled panel
	s_vOledWriteOneByteCmd(0x00, emDevNum);//---set low column address
	s_vOledWriteOneByteCmd(0x10, emDevNum);//---set high column address
	s_vOledWriteOneByteCmd(0x40, emDevNum);//--set start line address  Set Mapping RAM Display Start Line (0x00~0x3F)
	s_vOledWriteOneByteCmd(0x81, emDevNum);//--set contrast control register
	s_vOledWriteOneByteCmd(0xCF, emDevNum);// Set SEG Output Current Brightness
	s_vOledWriteOneByteCmd(0xA1, emDevNum);//--Set SEG/Column Mapping     0xa0左右反置 0xa1正常
	s_vOledWriteOneByteCmd(0xC8, emDevNum);//Set COM/Row Scan Direction   0xc0上下反置 0xc8正常
	s_vOledWriteOneByteCmd(0xA6, emDevNum);//--set normal display
	s_vOledWriteOneByteCmd(0xA8, emDevNum);//--set multiplex ratio(1 to 64)
	s_vOledWriteOneByteCmd(0x3f, emDevNum);//--1/64 duty
	s_vOledWriteOneByteCmd(0xD3, emDevNum);//-set display offset	Shift Mapping RAM Counter (0x00~0x3F)
	s_vOledWriteOneByteCmd(0x00, emDevNum);//-not offset
	s_vOledWriteOneByteCmd(0xd5, emDevNum);//--set display clock divide ratio/oscillator frequency
	s_vOledWriteOneByteCmd(0x80, emDevNum);//--set divide ratio, Set Clock as 100 Frames/Sec
	s_vOledWriteOneByteCmd(0xD9, emDevNum);//--set pre-charge period
	s_vOledWriteOneByteCmd(0xF1, emDevNum);//Set Pre-Charge as 15 Clocks & Discharge as 1 Clock
	s_vOledWriteOneByteCmd(0xDA, emDevNum);//--set com pins hardware configuration
	s_vOledWriteOneByteCmd(0x12, emDevNum);
	s_vOledWriteOneByteCmd(0xDB, emDevNum);//--set vcomh
	s_vOledWriteOneByteCmd(0x40, emDevNum);//Set VCOM Deselect Level
	s_vOledWriteOneByteCmd(0x20, emDevNum);//-Set Page Addressing Mode (0x00/0x01/0x02)
	s_vOledWriteOneByteCmd(0x02, emDevNum);//
	s_vOledWriteOneByteCmd(0x8D, emDevNum);//--set Charge Pump enable/disable
	s_vOledWriteOneByteCmd(0x14, emDevNum);//--set(0x10) disable
	s_vOledWriteOneByteCmd(0xA4, emDevNum);// Disable Entire Display On (0xa4/0xa5)
	s_vOledWriteOneByteCmd(0xA6, emDevNum);// Disable Inverse Display On (0xa6/a7) 
	s_vOledWriteOneByteCmd(0xAF, emDevNum);
}


/// @brief      设备初始化
///
/// @param      pstHardParam    ：输入硬件参数指针
///             emDevNum        ：设备号
/// @note
void vOledDeviceInit(stOledStaticParamTdf *pstStaticParam, emOledDevNumTdf emDevNum)
{
    s_vOledStaticParamInit(pstStaticParam, emDevNum);
    
    vOledCmdInit(emDevNum);
}
